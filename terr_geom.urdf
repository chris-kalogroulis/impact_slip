Commit message: created optimisation program

File: terr_geom.urdf (robot description, URDF)
Before this commit: robot generated_robot, 1 links, 0 joints
Links:
- link terrain: geometry collision box size=0.01 0.5 0.005; collision box size=0.01 0.5 0.005
